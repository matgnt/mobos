require ofono.inc

PR = "4"

#SRC_URI = "git://git.kernel.org/pub/scm/network/ofono/ofono.git;protocol=git;tag=6786b722a280b210c7d1febfe73110ec4512b0e6"
SRC_URI = "git:///home/data/projects/topas/ofono/;tag=matgnt-wavecom"

S = "${WORKDIR}/git"

