require ofono.inc

#SRC_URI += "\
#    file://0001-Change-signalfd-include-path-from-sys-to-linux.patch;patch=1 \
#"
