require ofono.inc

SRC_URI[md5sum] = "bf427f7b859ca325b13c651c41e82459"
SRC_URI[sha256sum] = "13b1b1b44b21efda761fd60d2aae0720b248fbf4d1a85b24804e9cfee707c08d"
