require recipes/linux/linux_2.6.32.bb


